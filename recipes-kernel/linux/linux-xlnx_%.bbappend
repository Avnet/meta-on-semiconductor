FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://user_ap1302.cfg \
            file://0001-Adding-v4l-control-for-the-ap1302-AF-Flip-3d-path.patch \
            "
